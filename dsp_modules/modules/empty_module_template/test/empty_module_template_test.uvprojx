# Keil uVision project empty_module_template_test.uvprojx, settings and files
target Simulator (ARM-GNU)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: empty_module_template_test
  group System
    ../../../libraries/arm_mp4f/: keildbg_io.c startup_ARMCM4.c system_ARMCM4.c ARMCM4.h keildbg_io.h system_ARMCM4.h system_sim.h rsrc.h
  group main
    ./: filenames.h empty_module_template_test_arm.c
  group Scripts
    ./: debug.ini makefile mod_openfile.ini
    ../../../libraries/arm_mp4f/: gcc_arm.ld
  group c
    ../c/: empty_module_template.c empty_module_template.h
